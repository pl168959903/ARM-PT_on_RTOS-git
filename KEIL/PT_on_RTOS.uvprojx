# Keil uVision project PT_on_RTOS.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO103ZD3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: PT_on_RTOS +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Libraries\CMSIS\Include;..\Libraries\Device\Nuvoton\Nano103\Include;..\Libraries\StdDriver\inc;..\Libraries\User\inc;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\Config;..\include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../: main.c portable.c
  group CMSIS
    ../Libraries/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../Libraries/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group Libraries
    ../Libraries/StdDriver/src/: acmp.c adc.c clk.c crc.c fmc.c gpio.c i2c.c pdma.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group User_Lib
    ../Libraries/User/src/: FIFO.c Flash.c IRQ.c nrf24l01.c user_lib.c W25QXX.c CJ_OV528.c vMemAlloc.c

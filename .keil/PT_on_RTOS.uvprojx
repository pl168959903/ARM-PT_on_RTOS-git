# Keil uVision project PT_on_RTOS.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO103ZD3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: PT_on_RTOS +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\ARMCC\include;..\include;..\libraries\Official\CMSIS\Include;..\libraries\Official\Device\Nuvoton\Nano103\Include;..\libraries\Official\StdDriver\inc;..\libraries\User\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Libraries_user
    ../libraries/User/src/: CJ_OV528.c fifo.c NRF_P2P.c NRF24L01.c vMemAlloc.c W25QXX.c
  group Source
    ../Source/: irq.c main.c portable.c project.c
  group CMSIS
    ../libraries/Official/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../libraries/Official/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group Libraries_Official
    ../libraries/Official/StdDriver/src/: clk.c gpio.c retarget.c rtc.c sys.c spi.c timer.c uart.c
